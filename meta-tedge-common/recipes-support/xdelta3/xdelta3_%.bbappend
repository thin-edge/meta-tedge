PACKAGECONFIG:append = " lzma"