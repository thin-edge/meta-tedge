FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Sync-counters-on-startup-to-avoid-jump-in-counters-w.patch"
