dirs755:remove:tedge-logs = "${localstatedir}/volatile/log"
volatiles:remove:tedge-logs = "log"

volatiles:append:tedge-logs = "tmp"
dirs755:append:tedge-logs = "${localstatedir}/log"
