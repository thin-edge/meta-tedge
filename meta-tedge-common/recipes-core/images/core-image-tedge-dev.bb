require core-image-tedge.bb

IMAGE_INSTALL:append = " \
    mosquitto-clients \
"
