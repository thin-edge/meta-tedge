require recipes-extended/images/core-image-full-cmdline.bb

IMAGE_INSTALL += "tedge tedge-mapper mosquitto"
