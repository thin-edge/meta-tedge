dirs755:remove = "${localstatedir}/volatile/log"
volatiles:remove = "log"

volatiles:append = "tmp"
dirs755:append = "${localstatedir}/log"