SRCREV_tedge = "f743fa11586d4a3598bbe8ed951f66ab36bf0379"
SRCREV_tedge-services = "f495b82f0002be81a7778483003139a223a508a1"
SRCREV_FORMAT = "tedge"

require tedge-p11-server.inc
