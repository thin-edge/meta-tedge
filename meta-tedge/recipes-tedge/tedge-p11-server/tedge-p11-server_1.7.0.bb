SRCREV_tedge = "404a0c54d811ae107c43b574a0829cc8fa5153e1"
SRCREV_tedge-services = "f495b82f0002be81a7778483003139a223a508a1"
SRCREV_FORMAT = "tedge"
S = "${WORKDIR}/git"

require tedge-p11-server.inc
