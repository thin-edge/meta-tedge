SRCREV_tedge = "19662f12d8df2ad0bab60d749e4133b4dbd7844e"
SRCREV_tedge-services = "056c9bdbaf77435c9bb3a613a5e2e67100432283"
SRCREV_FORMAT = "tedge"

require tedge-p11-server.inc
