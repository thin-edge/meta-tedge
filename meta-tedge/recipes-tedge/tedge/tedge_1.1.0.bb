SRCREV_tedge = "ea66825c0f83d48a1fe8c38acce8765fe172b22c"
SRCREV_tedge-services = "${AUTOREV}"
SRCREV_FORMAT = "tedge"
S = "${WORKDIR}/git"

TEDGE_EXCLUDE = "c8y-firmware-plugin"

require tedge.inc
