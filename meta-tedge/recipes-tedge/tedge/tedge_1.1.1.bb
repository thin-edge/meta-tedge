SRCREV_tedge = "8bd6a3aba02560950b51901f5ff6ec855f53ee81"
SRCREV_tedge-services = "17b8e2e98ce2bc9f36be21701e557e959a686968"
SRCREV_FORMAT = "tedge"

TEDGE_EXCLUDE = "c8y-firmware-plugin"

require tedge.inc
