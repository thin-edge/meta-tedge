SRCREV_tedge = "0866b9b9d7571f1479571d0600a42923a9b2980f"
SRCREV_tedge-services = "17b8e2e98ce2bc9f36be21701e557e959a686968"
SRCREV_FORMAT = "tedge"

TEDGE_EXCLUDE = "c8y-firmware-plugin"

require tedge.inc
