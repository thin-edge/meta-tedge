SRCREV_tedge = "e7c50099ce6b418c411e1ae049b3c6d997c18a1f"
SRCREV_tedge-services = "f495b82f0002be81a7778483003139a223a508a1"
SRCREV_FORMAT = "tedge"
S = "${WORKDIR}/git"

TEDGE_EXCLUDE = "c8y-firmware-plugin"

require tedge.inc
