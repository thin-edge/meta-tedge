SRCREV_tedge = "35bd52846edde1bce7ac3648da875c0f962d9cf3"
SRCREV_tedge-services = "82b04d374890f48d885953570ff101c551660a0b"
SRCREV_FORMAT = "tedge"

TEDGE_EXCLUDE = "c8y-firmware-plugin"

require tedge.inc
require tedge-diag.inc
require tedge-log.inc
require tedge-config.inc
require tedge-flows.inc
