# Fix issue with `proc_macro` crate not being included in stdlib

S = "${RUSTSRC}/library/sysroot"
