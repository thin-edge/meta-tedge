require tedge-full-image.bb

IMAGE_INSTALL:append = " \
    tedge-state-scripts \
"
